# IAR project CONTROL_ECU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C123GH6PM
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295\inc; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib; C:\ti\TivaWare_C_Series-2.2.0.295; C:\Users\Lenovo\Desktop\Senior-1\Fall 2025\CSE211 Introduction to Embedded Systems\Project\Door_Lock_System\CONTROL_ECU\CONFIG; C:\Users\Lenovo\Desktop\Senior-1\Fall 2025\CSE211 Introduction to Embedded Systems\Project\Door_Lock_System\CONTROL_ECU\APP; C:\Users\Lenovo\Desktop\Senior-1\Fall 2025\CSE211 Introduction to Embedded Systems\Project\Door_Lock_System\CONTROL_ECU\HAL; C:\Users\Lenovo\Desktop\Senior-1\Fall 2025\CSE211 Introduction to Embedded Systems\Project\Door_Lock_System\CONTROL_ECU\MCAL; C:\Users\Lenovo\Desktop\Senior-1\Fall 2025\CSE211 Introduction to Embedded Systems\Project\Door_Lock_System\CONTROL_ECU\SERVICES; C:\Users\Lenovo\Desktop\Senior-1\Fall 2025\CSE211 Introduction to Embedded Systems\Project\Door_Lock_System\CONTROL_ECU\UTILS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CONTROL_ECU.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ./: main.c
  group CONFIG
    CONFIG/: Led_Cfg.h
  group HAL
    HAL/: Button.c Button.h Door_Lock.c Door_Lock.h Led.c Led.h Memory_Manager.c Memory_Manager.h
  group MCAL
    MCAL/: Dio.c Dio.h EEPROM_Driver.c EEPROM_Driver.h SYSTICK.c SYSTICK.h
  group UTILS
    UTILS/: std_types.h
