<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\Downloads\01-LED-Switch\01-LED-Switch\01-LED-Switch.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\CONTROL_ECU\CONTROL_ECU.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\HMI_ECU\HMI_ECU.ewp</path>
    </project>
    <batchBuild />
</workspace>
